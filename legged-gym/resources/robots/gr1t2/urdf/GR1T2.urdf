Commit message: Update GR1T2.urdf

File: legged-gym/resources/robots/gr1t2/urdf/GR1T2.urdf (robot description, URDF)
Before this commit: robot GR1T2, 35 links, 34 joints
Links:
- link link_head_pitch: geometry visual mesh filename=../meshes/head3.STL
